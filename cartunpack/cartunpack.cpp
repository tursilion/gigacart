// cartunpack.cpp : Defines the entry point for the console application.
//

#include "stdafx.h"
#include <stdio.h>
#include <string.h>

/*

Video Cartridge layout:

CartHeader - 32 bytes
Bootpage   - 8k

First 8k - boot software

Each page
	32 bytes - cart header
	7688 bytes - interleaved a/v
	472 bytes - padding
	
Last page index at >600A (is last page index - 0x6002 + (pagecount*2) )

Non-cart version is just packed solid, no padding.

So, this program will build a new packed output file, skipping the boot page.
If you pass -n, it starts a new file, else it concatenates.

*/

FILE *in, *out;

void fail() {
    printf("cartunpack infile.bin [-n] output\n");
    printf("Takes a video file (pre-cart!) and combines it with others.\n");
    printf("If -n is passed, a new output file is created, else it concatenates.\n");
    printf("In the end, it is still just a raw video file and needs packing for the cart\n");
}

int main(int argc, char *argv[])
{
    int arg = 2;

    if (argc < 3) {
        fail();
        return 1;
    }

    in = fopen(argv[1], "rb");
    if (NULL == in) {
        printf("Can't open input file '%s'\n", argv[arg]);
        return 2;
    }

    if (0 == strcmp(argv[arg], "-n")) {
        ++arg;
        if (argc < 4) {
            fail();
            return 1;
        }
        out = fopen(argv[arg], "wb");
    } else {
        out = fopen(argv[arg], "ab");
    }
    if (NULL == out) {
        printf("Can't open output file '%s'\n", argv[arg+1]);
        fclose(in);
        return 2;
    }

    unsigned char buf[8192];

    // now read all the pages
    while (!feof(in)) {
        if (7688 != fread(buf, 1, 7688, in)) break;
        fwrite(buf, 1, 7688, out);
    }

    fclose(out);
    fclose(in);

    return 0;
}

