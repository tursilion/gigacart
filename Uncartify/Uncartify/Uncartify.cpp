// Uncartify.cpp : Defines the entry point for the console application.
//

#include "stdafx.h"
#include <stdio.h>
#include <errno.h>

int main(int argc, char *argv[])
{
    if (argc<2) {
        printf("uncartify <inputfile>\n");
        printf("Removes the 0xAA header byte from each page of a TI cart image\n");
        return 1;
    }
    FILE *fp=fopen(argv[1], "rb+");
    if (NULL == fp) {
        printf("Can't open %s, code %d\n", argv[1], errno);
        return 1;
    }
    fseek(fp, 0, SEEK_END);
    int size = ftell(fp);
    int pos = 0;
    while (!feof(fp)) {
        if (pos >= size) break;
        if (fseek(fp, pos, SEEK_SET)) {
            printf("seek failed, code %d\n", errno);
            break;
        }
        if (fgetc(fp) != 0xaa) {
            printf("Offset 0x%X was not a 0xAA byte, stopping.\n", pos);
            break;
        }
        if (fseek(fp, pos, SEEK_SET)) {
            printf("Second seek failed, code %d\n", errno);
            break;
        }
        fputc(0x55, fp);
        pos+=8192;
    }
    fclose(fp);
    printf("** done **\n");


    return 0;
}

